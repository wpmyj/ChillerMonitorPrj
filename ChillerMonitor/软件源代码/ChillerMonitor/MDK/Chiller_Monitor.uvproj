# Keil uVision project Chiller_Monitor.uvproj, settings and files
target Chiller_Monitor (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Chiller_Monitor +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\CMSIS;..\FWlib\inc;..\USER\inc;.\APP
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group startup
    ../CMSIS/startup/: startup_stm32f10x_hd.s
  group USER
    ../USER/src/: key.c led.c Delay_Timer.c J12864.c Display.c Timer.c IO_Process.c Tempra_AD.c STM32Flash.c
  group FWlib
    ../FWlib/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_flash.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group MDK
    ./APP/: main.c stm32f10x_it.c
